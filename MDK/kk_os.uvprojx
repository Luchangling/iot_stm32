# Keil uVision project kk_os.uvprojx, settings and files
target kk_os (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kk_os +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\app;..\arch;..\arch\board;..\arch\core;..\arch\cpu;..\arch\board\stm32;..\arch\core\arm;..\arch\core\arm\m3;..\arch\cpu\stm32\inc;..\driver;..\driver\seril;..\os;..\os\config;..\os\core;..\os\port;..\osconf;..\public;..\public\fifo;..\service;..\driver\fs
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../app/: main.c
  group service
    ../service/: service_log.c at_client.c l610_socket_service.c socket_service.c gps.c nmea_protocol.c led_service.c gps_save.c gps_service.c protocol.c protocol_jt808.c update_file.c update_service.c command.c sensor_service.c agps_service.c
    ../app/: socket.c gprs.c system_state.c
    ../driver/fs/: config_service.c fs_api.c stmflash.c
  group public
    ../public/fifo/: fifo.c
    ../public/: json.c utility.c applied_math.c circular_queue.c
  group osconf
    ../osconf/: kk_os_config_api.c
  group os
    ../os/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../os/port/: os_cpu_c.c os_cpu_a.asm
  group arch
    ../arch/board/stm32/: gpio_board_config.c i2c_board_config.c spi_flash_board_config.c uart_board_config.c
    ../arch/board/: board.c
  group core
    ../arch/cpu/stm32/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c
    ../arch/core/arm/m3/: core_cm3.c startup_stm32f10x_hd.s
